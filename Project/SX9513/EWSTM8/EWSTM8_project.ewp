# IAR project EWSTM8_project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Libraries\STM8_TouchSensing_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: EWSTM8_project.hex
  ILINK.IlinkOutputFile: EWSTM8_project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../inc/: misc.h soft_i2c.h stm8s_conf.h stm8s_it.h sx9513.h
  group Source Files
    ../src/: main.c misc.c soft_i2c.c stm8s_it.c sx9513.c
  group STM8S_StdPeriphLib/inc
    ../../../Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_clk.h stm8s_exti.h stm8s_gpio.h stm8s_i2c.h
  group STM8S_StdPeriphLib/src
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c
